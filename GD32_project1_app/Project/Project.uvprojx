# Keil uVision project Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin --output .\Objects\Project.bin .\Objects\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Firmware\Include;..\CMSIS;..\FreeRTOS\include;..\FreeRTOS\port
  memory RVCT4: ROM 0x8004000 size 0xb000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: gd32f10x_it.c main.c systick.c i2c_hw.c i2c_hw.h i2c_sw.c i2c_sw.h OLED_I2C.c OLED_I2C.h HOOK_DEF.c spi_sw.h spi_sw.c spi_hw.h spi_hw.c w25q64.h w25q64.c sensor.c sensor.h bootloader_start.h bootloader_start.c i2c_types.h i2c_backend.h
  group CMSIS
    ../CMSIS/: system_gd32f10x.c startup_gd32f10x_md.s
  group Firmware
    ../Firmware/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group FreeRTOS
    ../FreeRTOS/src/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/port/: heap_4.c port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
