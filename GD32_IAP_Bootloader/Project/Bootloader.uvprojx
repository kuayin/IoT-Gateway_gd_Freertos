# Keil uVision project Bootloader.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: fromelf --bin --output .\Objects\Bootloader.bin .\Objects\Bootloader.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -Wno-inline-asm
  c include: ..\CMSIS;..\Firmware\Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: system_gd32f10x.c startup_gd32f10x_md.s
  group User
    ../User/: boot_uart.c boot_uart.h main.c spi_hw.c ymodem.h w25q64.c ymodem.c iap.h iap.c
  group Firmware
    ../Firmware/Source/: gd32f10x_bkp.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_misc.c gd32f10x_spi.c gd32f10x_crc.c
